<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BROADCAST.ewp</path>
    </project>
    <batchBuild />
</workspace>
