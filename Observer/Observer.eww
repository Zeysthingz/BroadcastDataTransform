<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\eren-test\ALICI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Observer.ewp</path>
    </project>
    <batchBuild />
</workspace>
